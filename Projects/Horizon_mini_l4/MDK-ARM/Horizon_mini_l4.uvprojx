# Keil uVision project Horizon_mini_l4.uvprojx, settings and files
target Horizon_mini_l4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Horizon_mini_l4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L432xx,USE_HAL_DRIVER,HORIZON_MINI_L4
  c include: ..\..\..\Codebase\Application\inv;..\..\..\Codebase\FreeRTOS\Source\include;..\..\..\Codebase\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\Codebase\al\stm32l4xx\inc;..\..\..\Codebase\BSP\NUCLEO-L432KC\Inc;..\..\..\Codebase\Drivers\CMSIS\Include;..\..\..\Codebase\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Codebase\Drivers\STM32L4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application
    ../../../Codebase/Application/: main.c
    ../../../Codebase/Application/inv/: inv_mpu.c
  group AL
    ../../../Codebase/al/stm32l4xx/src/: al_stm32l4xx_i2c.c al_stm32l4xx_uart.c al_stm32l4xx_util.c
  group FreeRTOS
    ../../../Codebase/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../Codebase/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Codebase/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group BSP
    ../../../Codebase/BSP/NUCLEO-L432KC/Src/: nucleo_l432kc_bsp.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../../../Codebase/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l432xx.s
    ../../../Codebase/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/HAL
    ../../../Codebase/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
