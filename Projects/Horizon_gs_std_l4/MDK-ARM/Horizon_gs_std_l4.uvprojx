# Keil uVision project Horizon_gs_std_l4.uvprojx, settings and files
target Horizon_gs_std_l4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Horizon_gs_std_l4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,HORIZON_GS_STD_L4
  c include: ..\..\..\Codebase\Application\BOSCH\BMP280_driver;..\..\..\Codebase\Application\NORDIC\nRF24L01;..\..\..\Codebase\al\stm32l4xx\inc;..\..\..\Codebase\FreeRTOS\Source\include;..\..\..\Codebase\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\Codebase\BSP\NUCLEO-L476RG\Inc;..\..\..\Codebase\Drivers\CMSIS\Include;..\..\..\Codebase\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Codebase\Drivers\STM32L4xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application
    ../../../Codebase/Application/: main.c
    ../../../Codebase/Application/BOSCH/BMP280_driver/: bmp280.c
    ../../../Codebase/Application/NORDIC/nRF24L01/: nrf24l01.c
  group AL
    ../../../Codebase/al/stm32l4xx/src/: al_stm32l4xx_i2c.c al_stm32l4xx_spi.c al_stm32l4xx_uart.c al_stm32l4xx_util.c
  group FreeRTOS
    ../../../Codebase/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../Codebase/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Codebase/FreeRTOS/Source/portable/MemMang/: heap_1.c
  group BSP
    ../../../Codebase/BSP/NUCLEO-L476RG/Src/: nucleo_l476rg_bsp.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../../../Codebase/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
    ../../../Codebase/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/HAL
    ../../../Codebase/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
